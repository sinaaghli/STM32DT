# IAR project bldc_drive.ewp, settings and files
configuration bldc_drive Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VC ST STM32F207VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F207xx
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F2xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F2xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: bldc_drive Configuration.out
  ILINK.IlinkIcfFile: stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Drivers
    ./: 
  group Drivers/STM32F2xx_HAL_Driver
    ./: 
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_flash.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pwr.c stm32f2xx_hal.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_tim_ex.c
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f207xx.s
  group Application/User
    ./: 
    ../Src/: stm32f2xx_it.c stm32f2xx_hal_msp.c main.c gpio.c tim.c
