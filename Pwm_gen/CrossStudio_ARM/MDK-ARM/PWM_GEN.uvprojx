# Keil uVision project PWM_GEN.uvprojx, settings and files
target PWM_GEN Configuration (ARM-ADS)
  device: STM32F217VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PWM_GEN Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F217xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F2xx/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_cortex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f217xx.s
  group Application/User
    ../Src/: gpio.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c tim.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
software components: CMSIS:CORE 4.1.0
